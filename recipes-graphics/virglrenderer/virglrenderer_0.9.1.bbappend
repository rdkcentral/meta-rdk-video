SRC_URI:remove = "git://anongit.freedesktop.org/git/virglrenderer;branch=branch-0.9.1"

SRC_URI:append = " git://anongit.freedesktop.org/git/virglrenderer;protocol=https;branch=branch-0.9.1"
