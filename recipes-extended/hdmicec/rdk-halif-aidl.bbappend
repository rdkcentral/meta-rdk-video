PROVIDES += "virtual/vendor-hdmicec-hal"
RPROVIDES:${PN} = "virtual/vendor-hdmicec-hal"
