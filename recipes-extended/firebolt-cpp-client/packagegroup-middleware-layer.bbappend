RDEPENDS:${PN} += " fbt-test"
