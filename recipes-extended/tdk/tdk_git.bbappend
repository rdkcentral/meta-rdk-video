# Remove aamp dependency - building without aamp
DEPENDS:remove = "aamp"
