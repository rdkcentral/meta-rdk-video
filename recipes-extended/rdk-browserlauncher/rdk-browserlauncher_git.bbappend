# Remove wpe-webkit dependency - building without webkit
DEPENDS:remove = "wpe-webkit"
