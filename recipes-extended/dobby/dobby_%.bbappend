RDEPENDS:${PN} += "libstdc++6 libgcc"
