# Remove unconditional webkit dependency - building without wpe-webkit
RDEPENDS_${PN}:remove = "webkitbrowser-plugin"
