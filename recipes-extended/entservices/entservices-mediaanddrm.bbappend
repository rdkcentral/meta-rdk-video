# Temporary TTS build troubleshooting.
PACKAGECONFIG:remove = "texttospeech"
