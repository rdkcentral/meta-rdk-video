# Temporary TTS build troubleshooting.
PLUGIN_MONITOR_INSTANCES_LIST:remove = "org.rdk.TextToSpeech,0,0,1,60,3"
