# Temporary TTS build troubleshooting; rdkat requires TTS.
EXCLUDE_FROM_WORLD = "1"
