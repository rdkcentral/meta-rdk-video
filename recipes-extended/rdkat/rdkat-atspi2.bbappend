# Temporary TTS build troubleshooting; rdkat-atspi2 requires TTS.
EXCLUDE_FROM_WORLD = "1"
