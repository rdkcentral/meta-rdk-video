# Remove aamp - building without aamp
RDEPENDS:packagegroup-cpc-mediaserver:remove = "aamp"
