# Remove aamp - building without aamp
RDEPENDS:packagegroup-cpc-mediaclient:remove = "aamp"
