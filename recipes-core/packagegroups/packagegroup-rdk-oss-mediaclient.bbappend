RDEPENDS:packagegroup-rdk-oss-mediaclient:append = "\
    avahi-daemon \
    avahi-autoipd \
    "
