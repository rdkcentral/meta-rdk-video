
PACKAGE_ARCH = "${MIDDLEWARE_ARCH}"
