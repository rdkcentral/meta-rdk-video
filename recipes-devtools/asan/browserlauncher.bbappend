include enable_asan.inc