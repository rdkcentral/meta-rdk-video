require ./thunder-extensions.inc

# tip of main for now, repo doesn't have R5 relates tags
SRCREV:thunder_5 = "9e235b0e9f7b6e5833c69aed1ad360a3214a0b67"