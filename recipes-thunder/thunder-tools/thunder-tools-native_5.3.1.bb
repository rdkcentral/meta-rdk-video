require ./thunder-tools.inc

SRC_URI += " file://0001-Change-MODULE-PATH.patch "
SRC_URI += " file://0005-Autostart-startmode-deactivated.patch"

SRCREV = "b70113d451e582e762822f1e93258b57dace8b42"