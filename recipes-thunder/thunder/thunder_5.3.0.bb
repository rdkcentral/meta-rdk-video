require ./thunder.inc

SRC_URI += " \
    file://0002-PersistentPath-thunder-r5.patch \
"
