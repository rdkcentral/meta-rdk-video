SUMMARY = "cpeabs- Handle patches"
HOMEPAGE = "https://github.com/xmidt-org/cpeabs"

EXTRA_OECMAKE += "-DPLATFORM=DEVICE_VIDEO"
