SRC_URI += "file://wdmp-c.patch"
FILESEXTRAPATHS:prepend:= "${THISDIR}/files:"
