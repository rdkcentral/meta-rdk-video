# Minimal placeholder for environments without the full RDK logrotate integration.
