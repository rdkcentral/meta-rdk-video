# Minimal placeholder for environments without the full RDK coverity integration.
