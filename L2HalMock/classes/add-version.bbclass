# Minimal placeholder for environments without the full RDK add-version integration.
