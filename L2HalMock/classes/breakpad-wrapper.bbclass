# Minimal placeholder for environments without the full RDK breakpad wrapper integration.
