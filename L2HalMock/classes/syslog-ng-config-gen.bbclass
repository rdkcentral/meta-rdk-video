# Minimal placeholder for environments without the full RDK syslog-ng integration.
